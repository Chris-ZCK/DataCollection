# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE;..\HARDWARE\PWR;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\RTC;..\HARDWARE\IWDG;..\HARDWARE\USART3;..\HARDWARE\USART2;..\HARDWARE\RNG;..\APP;..\APP\EC25;..\APP\My_lib;..\HARDWARE\STMFLASH;..\APP\MQTTPacket\src;..\APP\MQTTPacket\ops;..\APP\FATFS\exfuns;..\APP\FATFS\src;..\APP\FATFS\src\option;..\APP\MALLOC;..\HARDWARE\SDIO;..\HARDWARE\SESR;..\HARDWARE\IIC;..\HARDWARE\MAX44009;..\HARDWARE\SHT;..\HARDWARE\SPI;..\HARDWARE\MS5611;..\HARDWARE\BATTERY;..\HARDWARE\GPS;..\APP\USB;..\APP\USB\USB_APP;..\APP\USB\STM32_USB_OTG_Driver\inc;..\APP\USB\STM32_USB_HOST_Library\Core\inc;..\APP\USB\STM32_USB_HOST_Library\Class\MSC\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/PWR/: power.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/RNG/: rng.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SESR/: sensor.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/BATTERY/: battery.c
    ../HARDWARE/IIC/: myiic_max44009.c myiic_sht20.c
    ../HARDWARE/MAX44009/: max44009.c
    ../HARDWARE/SHT/: SHT2x.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/MS5611/: ms5611.c
    ../HARDWARE/GPS/: gps.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_rng.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group EC25
    ../APP/EC25/: ec25.c UART_TCPbuff.c
  group MY_LIB
    ../APP/My_lib/: MyFunction_C.c Queue.c
  group MQTT_LIB
    ../APP/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group MQTT_OPS
    ../APP/MQTTPacket/ops/: mqttApp.c mqttBase.c mqttTransport.c
  group FATFS
    ../APP/FATFS/exfuns/: exfuns.c fattester.c
    ../APP/FATFS/src/: diskio.c ff.c
    ../APP/FATFS/src/option/: unicode.c
  group MALLOC
    ../APP/MALLOC/: malloc.c
  group USB_OTG
    ../APP/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../APP/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../APP/USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../APP/USB/USB_APP/: usb_app.c usb_bsp.c usbh_usr.c
